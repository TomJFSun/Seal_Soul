# Keil uVision project config1.uvprojx, settings and files
target config1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L071RBTx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.1.6.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: config1 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L071xx,__TARGET_FPU_VFP_DOUBLE,_REF2V5
  c misc: --C99
  c include: ../Inc;../Drivers/STM32L0xx_HAL_Driver/Inc;../Drivers/STM32L0xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32L0xx/Include;../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --diag_suppress=L6329
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32L0xx/Source/Templates/: system_stm32l0xx.c
  group Drivers/STM32L0xx_HAL_Driver
    ../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_rtc_ex.c stm32l0xx_hal_wwdg.c stm32l0xx_hal_gpio.c stm32l0xx_hal_dma.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_i2c.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_rtc.c stm32l0xx_hal_tim.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_pwr.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal_uart.c stm32l0xx_hal_spi.c stm32l0xx_hal.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_adc.c stm32l0xx_hal_rcc.c stm32l0xx_hal_flash.c
  group Application/MDK-ARM
    ./: startup_stm32l071xx.s
  group Application/User
    ../Src/: main.c stm32l0xx_hal_msp.c stm32l0xx_it.c spiflash.c delay.c pwm_tim2.c key.c gpio_i2c.c adc.c battery.c ads1115.c elec_sw.c cat9555.c usart.c test_seq.c short_test.c open_test.c e_ink.c
software components: CMSIS:CORE 3.40.0
